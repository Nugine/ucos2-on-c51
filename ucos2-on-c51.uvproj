# Keil uVision project ucos2-on-c51.uvproj, settings and files
target main (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: main.omf
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51
